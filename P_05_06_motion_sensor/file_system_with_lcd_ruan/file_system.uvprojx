# Keil uVision project file_system.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: file_system
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx, USE_STM32F429I_DISCO, USE_HAL_DRIVER
  c include: .\inc;.\Drivers\STM32F4xx_HAL_Driver\Inc;.\Drivers\BSP\STM32F429I-Discovery;.\Drivers\FatFs\src;.\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Drivers\CMSIS\Include;.\Drivers\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: accelerometer.c bsp_driver_sd.c fatfs_platform.c main.c sd_diskio.c sdio.c spi.c stm32f4xx_it.c system_stm32f4xx.c mc1_fs_board.c file_io.c display.c error.c
  group MDK-ARM
    ./MDK-ARM/: startup_stm32f429xx.s
  group Drivers
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_ltdc.c
    ./Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery_lcd.c stm32f429i_discovery.c
  group Drivers/Component
    ./Drivers/BSP/Components/ili9341/: ili9341.c
  group FatFs
    ./Drivers/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ./Drivers/FatFs/src/option/: syscall.c unicode.c
